# Keil uVision project lab5.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\APP;.\BSP;.\CPU;.\LIB;.\RTE\Device;.\RTE;.\UCOS\Source;.\UCOS;.\RTE\Device\STM32F103C8;.\HARDWARE;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./APP/: app.c app_cfg.h includes.h os_cfg.h sys.h
  group UCOS
    ./UCOS/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group BSP
    ./BSP/: bsp.c bsp.h
  group LIB
    ./LIB/: lib_ascii.h lib_def.h lib_mem.h lib_str.h
  group CPU
    ./CPU/: cpu.h cpu_a.asm cpu_c.c os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c cpu_def.h
  group HARDWARE
    ./HARDWARE/: led.c led.h digits.c digits.h adc.c adc.h sound.c sound.h stm32f10x_tim.c stm32f10x_usart.c usart.c stm32f10x_adc.c timer.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
